options:
  parameters:
    generate_options: qt_gui
    id: intra_enb
    output_language: python
    title: Intra Handover Flowgraph
  states: {}

blocks:
- name: gain_enb1
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '10e-3'
    stop: '1'
    value: '1'
  states: {}
- name: gain_enb2
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '10e-3'
    stop: '1'
    value: '0'
  states: {}
- name: gain_ue1
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '100e-6'
    stop: '1'
    value: '1'
  states: {}
- name: gain_ue2
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '100e-6'
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    start: 1e5
    step: 1e5
    stop: 100e6
    value: 23.04e6
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain_enb1/100
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain_enb2/100
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain_ue2
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: gain_ue1
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2000
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2100
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_1_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2200
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2101
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2201
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_1
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2001
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_throttle_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', zeromq_rep_sink_1_0, '0']
- [blocks_multiply_const_vxx_0_0_1, '0', zeromq_rep_sink_1, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [blocks_throttle_0_0_0, '0', zeromq_rep_sink_0, '0']
- [zeromq_req_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [zeromq_req_source_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [zeromq_req_source_1, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
